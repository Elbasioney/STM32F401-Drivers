# Keil uVision project ARM Cortex-M4.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401CCFx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: discovery_drivers +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c main.h
  group RCC
    ./MCAL/RCC/: RCC_Private.h RCC_App.c RCC_interface.h RCC_Config.h
  group LIB
    ./LIB/: BIT_MATH.h Helper_Functions.c Helper_Functions.h STD_TYPES.h
  group GPIO
    ./MCAL/NVIC/: NVIC_App.c
    ./MCAL/GPIO/: GPIO_App.c GPIO_Config.h GPIO_Interface.h GPIO_Private.h
  group DMA
    ./MCAL/DMA/: DMA_App.c DMA_Config.h DMA_Interface.h DMA_Private.h
  group NVIC
    ./MCAL/NVIC/: NVIC_Config.h NVIC_Interface.h NVIC_Private.h NVIC_App.c
  group SYSTICK
    ./MCAL/SYSTICK/: SYSTICK_App.c SYSTICK_Config.h SYSTICK_Interface.h SYSTICK_Private.h
  group OS
    ./OS/: OS_App.c OS_Config.h OS_Interface.h OS_Private.h
  group ADC
    ./MCAL/ADC/: ADC_App.c ADC_Config.h ADC_Interface.h ADC_Private.h
  group EXTI
    ./MCAL/EXTI/: EXTI_App.c EXTI_Config.h EXTI_Interface.h EXTI_Private.h
  group SYSCFG
    ./MCAL/SYSCFG/: SYSCFG_App.c SYSCFG_Config.h SYSCFG_Interface.h SYSCFG_Private.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
